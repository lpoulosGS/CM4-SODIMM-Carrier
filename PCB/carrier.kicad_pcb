# Repository lpoulosGS/CM4-SODIMM-Carrier

## KiCad design PCB/carrier.kicad_pcb

Board: 6 copper layers, 69.6 x 46.1 mm, 124 parts (0 on the bottom side), 131 nets.

Parts:
C1, C1#2, C2, C2#2, C3, C4, C4#2, C5, C5#2, C6, C6#2, C8, C9, C10, C12, C14, C15, C16, C17, C19, C21: 0.1uF; C_0402_1005Metric
C7, C7#2, C13, C18: 1uF; C_0402_1005Metric
C11, C20: 10uF; C_0603_1608Metric
D1: Green; LED_0805_2012Metric
D2: Yellow; LED_0805_2012Metric
J1: SODIMM-260_Split; SODIMM_DDR4_EDGE
J2: Micro_SD_Card_Det2; microSD_HC_Hirose_DM3AT-SF-PEJM5
Module1: 10164227-1004A1RLF; Raspberry-Pi-4-Compute-Module-B
Module2: 10164227-1004A1RLF; Raspberry-Pi-4-Compute-Module-A
Q2, Q3, Q5: BSS138; SOT-23-3
Q4: BC817-40; SOT-323_SC-70
R1, R1#2, R15, R15#2: 330; R_0402_1005Metric
R2, R5, R6, R7, R8, R9, R10, R10#2, R11, R11#2, R12, R12#2, R13, R13#2, R16, R16#2, R17, R17#2, R18, R18#2, R19, R19#2, R20, R20#2, R21, R21#2, R22, R23, R24, R24#2, R25, R25#2: 10K; R_0402_1005Metric
R3, R4, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61: 0; R_0402_1005Metric
R14, R14#2: 12K; R_0402_1005Metric
SD_PWR1: TestPoint_Small; TestPoint_Pad_D1.0mm
SW1: SW_DIP_x04; SW_DIP_SPSTx04_Slide_Copal_CHS-04B_W7.62mm_P1.27mm
TP1, TP1#2: RTC Test; TestPoint_Pad_D1.0mm
TP2, TP2#2: Sleep Status Output; TestPoint_Pad_D1.0mm
U1: USB2514B/M2; SQFN36_6X6_MCH
U2, U3: SN74LVC8T245; TSSOP-24_4.4x5mm_P0.4mm
U4: RT9742GGJ5; TSOT-23-5
Y1: ECS-240-18-33Q-DS; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm

Connections:
+1V8: C13.2, C15.2, C17.1, Module2.78 (GPIO_VREF(1.8v/3.3v_Input)), Module2.88 (+1.8v_(Output)), Module2.90 (+1.8v_(Output)), R24.1, R24#2.1, U2.1 (V_{CCA}), U3.23 (V_{CCB}), U3.24 (V_{CCB})
+3V3: C3.1, C8.1, C9.1, C10.1, C12.1, C14.1, C18.1, C19.1, Module2.84 (+3.3v_(Output)), Module2.86 (+3.3v_(Output)), Q2.2 (G), Q3.2 (G), Q5.2 (G), R1.1, R1#2.1, R11.1, R11#2.1, R13.1, R13#2.1, R14.1, R14#2.1, R15.1, R15#2.1, R17.1, R17#2.1, R18.1, R18#2.1, R19.1, R19#2.1, R20.1, R20#2.1, R21.1, R21#2.1, R22.1, R23.1, R25.1, R25#2.1, U1.5 (VDDA33), U1.10 (VDDA33), U1.15 (VDD33), U1.23 (VDD33), U1.29 (VDDA33), U1.36 (VDDA33), U2.23 (V_{CCB}), U2.24 (V_{CCB}), U3.1 (V_{CCA}), U4.5 (VIN)
+5V: C1.1, C1#2.1, C2.1, C2#2.1, C4.1, C4#2.1, C5.1, C5#2.1, C6.1, C6#2.1, C7.1, C7#2.1, C11.1, J1.251 (VDD_IN), J1.252 (VDD_IN), J1.253 (VDD_IN), J1.254 (VDD_IN), J1.255 (VDD_IN), J1.256 (VDD_IN), J1.257 (VDD_IN), J1.258 (VDD_IN), J1.259 (VDD_IN), J1.260 (VDD_IN), Module2.77 (+5v_(Input)), Module2.79 (+5v_(Input)), Module2.81 (+5v_(Input)), Module2.83 (+5v_(Input)), Module2.85 (+5v_(Input)), Module2.87 (+5v_(Input)), R10.1, R10#2.1, R12.1, R12#2.1
ACTIVITY_LED: D1.1 (K), Module2.21 (PI_nLED_Activity)
CSI-0_CLK_N: Module1.127 (CSI0_C_N), R34.2
CSI-0_CLK_P: Module1.129 (CSI0_C_P), R35.2
CSI-0_D0_N: Module1.115 (CSI0_D0_N), R36.2
CSI-0_D0_P: Module1.117 (CSI0_D0_P), R37.2
CSI-0_D1_N: Module1.121 (CSI0_D1_N), R38.2
CSI-0_D1_P: Module1.123 (CSI0_D1_P), R39.2
CSI-0_D2_N: J1.3 (CSI_B_D0_N), Module1.133 (CSI0_D2_N), R40.2
CSI-0_D2_P: J1.5 (CSI_B_D0_P), Module1.135 (CSI0_D2_P), R41.2
CSI-0_D3_N: J1.15 (CSI_B_D1_N), Module1.139 (CSI0_D3_N), R42.2
CSI-0_D3_P: J1.17 (CSI_B_D1_P), Module1.141 (CSI0_D3_P), R43.2
CSI-0_SCL: J1.213 (CSI0_SCL), Module2.80 (SCL0)
CSI-0_SDA: J1.215 (CSI0_SDA), Module2.82 (SDA0)
CSI-1_CLK_N: Module1.187 (CSI1_CLK_N), R44.2
CSI-1_CLK_P: Module1.189 (CSI1_CLK_P), R45.2
CSI-1_D0_N: Module1.175 (CSI1_D0_N), R46.2
CSI-1_D0_P: Module1.177 (CSI1_D0_P), R47.2
CSI-1_D1_N: Module1.181 (CSI1_D1_N), R48.2
CSI-1_D1_P: Module1.183 (CSI1_D1_P), R49.2
FAN_PWM_1V8: J1.230 (FAN_PWM_1V8), U2.8 (A6)
FAN_PWM_3V3: Module2.19 (Ethernet_nLED1(3.3v)), U2.16 (B6)
FAN_TACH_1V8: J1.208 (Fan_TACH_1V8), U3.19 (B3)
FAN_TACH_3V3: Module2.16 (Ethernet_SYNC_IN(1.8v)), U3.5 (A3)
GBE_LED_ACT: J1.194 (GBE_LED_ACT), Module2.17 (Ethernet_nLED2(3.3v))
GBE_LED_LINK: J1.188 (GBE_LED_LINK), Module2.15 (Ethernet_nLED3(3.3v))
GBE_MDI0_N: J1.184 (GBE_MDIO_N), Module2.10 (Ethernet_Pair0_N)
GBE_MDI0_P: J1.186 (GBE_MDIO_P), Module2.12 (Ethernet_Pair0_P)
GBE_MDI1_N: J1.190 (GBE_MDI1_N), Module2.6 (Ethernet_Pair1_N)
GBE_MDI1_P: J1.192 (GBE_MDI1_P), Module2.4 (Ethernet_Pair1_P)
GBE_MDI2_N: J1.196 (GBE_MDI2_N), Module2.9 (Ethernet_Pair2_N)
GBE_MDI2_P: J1.198 (GBE_MDI2_P), Module2.11 (Ethernet_Pair2_P)
GBE_MDI3_N: J1.202 (GBE_MDI3_N), Module2.5 (Ethernet_Pair3_N)
GBE_MDI3_P: J1.204 (GBM_MDI3_P), Module2.3 (Ethernet_Pair3_P)
GND: C1.2, C1#2.2, C2.2, C2#2.2, C3.2, C4.2, C4#2.2, C5.2, C5#2.2, C6.2, C6#2.2, C7.2, C7#2.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, C15.1, C16.2, C17.2, C18.2, C19.2, C20.2, J1.1 (GND), J1.2 (GND), J1.7 (GND), J1.8 (GND), J1.13 (GND), J1.14 (GND), J1.19 (GND), J1.20 (GND), J1.25 (GND), J1.26 (GND), J1.31 (GND), J1.32 (GND), J1.37 (GND), J1.38 (GND), J1.43 (GND), J1.44 (GND), J1.49 (GND), J1.50 (GND), J1.55 (GND), J1.56 (GND), J1.61 (GND), J1.62 (GND), J1.67 (GND), J1.68 (GND), J1.73 (GND), J1.74 (GND), J1.79 (GND), J1.80 (GND), J1.85 (GND), J1.86 (GND), J1.102 (GND), J1.107 (GND), J1.113 (GND), J1.119 (GND), J1.125 (GND), J1.129 (GND), J1.132 (GND), J1.135 (GND), J1.138 (GND), J1.141 (GND), J1.144 (GND), J1.146 (GND), J1.147 (GND), J1.152 (GND), J1.153 (GND), J1.158 (GND), J1.159 (GND), J1.164 (GND), J1.165 (GND), J1.170 (GND), J1.171 (GND), J1.176 (GND), J1.177 (GND), J1.200 (GND), J1.201 (GND), J1.231 (GND), J1.241 (GND), J1.242 (GND), J1.243 (GND), J1.244 (GND), J1.245 (GND), J1.246 (GND), J1.247 (GND), J1.248 (GND), J1.249 (GND), J1.250 (GND), J2.6 (VSS), Module1.107 (GND), Module1.108 (GND), Module1.113 (GND), Module1.114 (GND), Module1.119 (GND), Module1.120 (GND), Module1.125 (GND), Module1.126 (GND), Module1.131 (GND), Module1.132 (GND), Module1.137 (GND), Module1.138 (GND), Module1.144 (GND), Module1.150 (GND), Module1.155 (GND), Module1.156 (GND), Module1.161 (GND), Module1.162 (GND), Module1.167 (GND), Module1.168 (GND), Module1.173 (GND), Module1.174 (GND), Module1.179 (GND), Module1.180 (GND), Module1.185 (GND), Module1.186 (GND), Module1.191 (GND), Module1.192 (GND), Module1.197 (GND), Module1.198 (GND), Module2.1 (GND), Module2.2 (GND), Module2.7 (GND), Module2.8 (GND), Module2.13 (GND), Module2.14 (GND), Module2.22 (GND), Module2.23 (GND), Module2.32 (GND), Module2.33 (GND), Module2.42 (GND), Module2.43 (GND), Module2.52 (GND), Module2.53 (GND), Module2.59 (GND), Module2.60 (GND), Module2.65 (GND), Module2.66 (GND), Module2.71 (GND), Module2.74 (GND), Module2.98 (GND), Q4.3 (E), R2.2, R5.2, R6.2, R7.2, R8.2, R9.2, SW1.1, SW1.2, SW1.3, SW1.4, U1.37 (VSS), U2.10 (A8), U2.11 (GND), U2.12 (GND), U2.13 (GND), U2.14 (B8), U3.11 (GND), U3.12 (GND), U3.13 (GND), U4.2 (GND), Y1.2 (GND), Y1.4 (GND)
GPIO0_1V8: J1.87, U2.3 (A1)
GPIO0_3V3: Module2.48 (GPIO27), U2.21 (B1)
HDMI-0_TX0_N: Module1.184 (HDMI0_TX0_N), R28.1
HDMI-0_TX0_P: Module1.182 (HDMI0_TX0_P), R29.1
HDMI-0_TX1_N: Module1.178 (HDMI0_TX1_N), R30.1
HDMI-0_TX1_P: Module1.176 (HDMI0_TX1_P), R31.1
HDMI-0_TX2_N: Module1.172 (HDMI0_TX2_N), R32.1
HDMI-0_TX2_P: Module1.170 (HDMI0_TX2_P), R33.1
I2C-0_SCL: J1.185 (I2C-0_SCL), Module2.47 (GPIO23)
I2C-0_SDA: J1.187 (I2C-0_SDA), Module2.46 (GPIO22)
LED_PWR: Module2.95 (nPI_LED_PWR), R16.2, R16#2.2
MOD_PWR_REQ: Module2.29 (GPIO16), Q3.3 (S), R13.2, R13#2.2
MOD_SLEEP: J1.178 (MOD_SLEEP), Module2.30 (GPIO6), TP2.1 (1_1), TP2#2.1 (1_1)
unnamed: D1.2 (A), R1.2, R1#2.2
unnamed: D2.2 (A), R15.2, R15#2.2
unnamed: D2.1 (K), Q4.1 (C)
unnamed: Q4.2 (B), R16.1, R16#2.1
unnamed: C16.1, U1.14 (CRFILT)
unnamed: C21.2, U1.34 (PLLFILT)
unnamed: U1.33 (XTALIN/CLKIN), Y1.3 (OUT/IN)
unnamed: U1.32 (XTALOUT), Y1.1 (IN/OUT)
unnamed: R8.1, U2.2 (DIR)
unnamed: R9.1, U2.22 (~OE)
unnamed: R6.1, U3.2 (DIR)
unnamed: R7.1, U3.22 (~OE)
PCIe_CLKREQ: J1.180 (PCIe_CLKREQ), Module1.102 (PCIe_CLK_nREQ)
PCIe_CLK_N: J1.160 (PCIE0_CLK_N), Module1.112 (PCIe_CLK_N)
PCIe_CLK_P: J1.162 (PCIe_CLK_P), Module1.110 (PCIe_CLK_P)
PCIe_RX_N: J1.131 (PCIE0_TX0_N), Module1.118 (PCIe_RX_N)
PCIe_RX_P: J1.133 (PCIE0_RX0_P), Module1.116 (PCIe_RX_P)
PCIe_TX_N: J1.134 (PCIE0_TX0_N), Module1.124 (PCIe_TX_N)
PCIe_TX_P: J1.136 (PCIE0_TX0_P), Module1.122 (PCIe_TX_P)
PCIe_WAKE_N: J1.179 (PCIE_WAKE), Module1.104 (PCIe_nWAKE)
PCIe_nRST: J1.181 (PCIe_nRST), Module1.109 (PCIe_nRST)
PMIC_EN: Module2.99 (Global_EN), Q2.3 (S), R11.2, R11#2.2, SW1.7
POWER_BMC: J1.237 (POWER_EN), Q2.1 (D), R10.2, R10#2.2
PWR_Button: Module2.92 (RUN_PG), SW1.8
RESET_BMC: J1.239 (SYS_RESET*), Q5.1 (D), R24.2, R24#2.2
SD_CLK: J2.5 (CLK), Module2.57 (SD_CLK)
SD_CMD: J2.3 (CMD), Module2.62 (SD_CMD), R20.2, R20#2.2
SD_DAT0: J2.7 (DAT0), Module2.63 (SD_DAT0), R18.2, R18#2.2
SD_DAT1: J2.8 (DAT1), Module2.67 (SD_DAT1), R17.2, R17#2.2
SD_DAT2: J2.1 (DAT2), Module2.69 (SD_DAT2), R21.2, R21#2.2
SD_DAT3: J2.2 (DAT3/CD), Module2.61 (SD_DAT3), R19.2, R19#2.2
SD_PWR: C20.1, J2.4 (VDD), SD_PWR1.1 (1_1), U4.1 (VOUT)
SD_PWR_ON: Module2.75 (SD_PWR_ON), R14.2, R14#2.2, U4.4 (EN)
SHUT_REQ_BMC: J1.233 (SHUTDOWN_REQ*), Q3.1 (D), R12.2, R12#2.2
SLEEP/WAKE: J1.240 (SLEEP/WAKE*), Module2.45 (GPIO24)
SPI-0_CLK_3V3: Module2.38 (GPIO11), R3.1
SPI-0_CS0_3V3: Module2.39 (GPIO8), R4.1
SPI-0_CS1_3V3: Module2.37 (GPIO7), R54.1
SPI-0_MISO_1V8: J1.93, U3.14 (B8)
SPI-0_MISO_3V3: Module2.40 (GPIO9), R55.1
SPI-0_MOSI_3V3: Module2.44 (GPIO10), R56.1
SPI-1_CLK_3V3: Module2.25 (GPIO21), R57.1
SPI-1_CS0_3V3: Module2.49 (GPIO18), R58.1
SPI-1_CS1_3V3: Module2.50 (GPIO17), R59.1
SPI-1_MISO_3V3: Module2.26 (GPIO19), R60.1
SPI-1_MOSI_3V3: Module2.27 (GPIO20), R61.1
SYS_RESET: Module2.41 (GPIO25), Q5.3 (S), R25.2, R25#2.2, SW1.5
UART-0_CTS_1V8: J1.105, U3.16 (B6)
UART-0_CTS_3V3: Module2.58 (GPIO2), U3.8 (A6)
UART-0_RTS_1V8: J1.103, U2.5 (A3)
UART-0_RTS_3V3: Module2.56 (GPIO3), U2.19 (B3)
UART-0_RX_1V8: J1.101, U3.15 (B7)
UART-0_RX_3V3: Module2.35 (ID_SC), U3.9 (A7)
UART-0_TX_1V8: J1.99, U2.4 (A2)
UART-0_TX_3V3: Module2.36 (ID_SD), U2.20 (B2)
UART-1_CTS_1V8: J1.209 (Uart-1_CTS_1V8), U3.20 (B2)
UART-1_CTS_3V3: Module2.55 (GPIO14), U3.4 (A2)
UART-1_RTS_1V8: J1.207 (Uart1_RTS_1V8), U2.7 (A5)
UART-1_RTS_3V3: Module2.51 (GPIO15), U2.17 (B5)
UART-1_RX_1V8: J1.205 (Uart-1_RX_1V8), U3.18 (B4)
UART-1_RX_3V3: Module2.28 (GPIO13), U3.6 (A4)
UART-1_TX_1V8: J1.203 (Uart-1-TX_1V8), U2.6 (A4)
UART-1_TX_3V3: Module2.31 (GPIO12), U2.18 (B4)
UART-2_RX_1V8: J1.238 (Uart-2_RX_1V8), U3.21 (B1)
UART-2_RX_3V3: Module2.34 (GPIO5), U3.3 (A1)
UART-2_TX_1V8: J1.236 (Uart-2_TX_1V8), U2.9 (A7)
UART-2_TX_3V3: Module2.54 (GPIO4), U2.15 (B7)
USB_N: Module1.103 (USB2_N), R26.1
USB_P: Module1.105 (USB2_P), R27.1
VBAT: J1.235 (PMIC_BBAT), Module2.76 (Reserved), TP1.1 (1_1), TP1#2.1 (1_1)
dCSI-0_CLK_N: J1.10 (CSI_A_CLK_N), R34.1
dCSI-0_CLK_P: J1.12 (CSI_A_CLK_P), R35.1
dCSI-0_D0_N: J1.4 (CSI_A_D0_N), R36.1
dCSI-0_D0_P: J1.6 (CSI_A_D0_P), R37.1
dCSI-0_D1_N: J1.16 (CSI_A_D1_N), R38.1
dCSI-0_D1_P: J1.18 (CSI_A_D1_P), R39.1
dSPI-0_MISO_3V3: R55.2, U3.10 (A8)
dSPI-1_MISO_3V3: R60.2, U3.7 (A5)
dUSB_N: J1.121, R26.2, U1.31 (USBDP_UP)
dUSB_P: J1.123, R27.2, U1.30 (USBDM_UP)
nRPIBOOT: Module2.93 (nRPIBOOT), SW1.6

Notices in the files:
PCB/carrier.kicad_pcb:
creativecommons.org/licenses/by/4.0
License: CC BY 4.0
